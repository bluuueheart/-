# Keil uVision project 5.13 测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 5.13 测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: emotions.c STARTUP.A51 main.c car.h motor_control.c
